<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\spi_slave_poll_halfduplex.ewp</path>
  </project>
  <batchBuild/>
</workspace>


