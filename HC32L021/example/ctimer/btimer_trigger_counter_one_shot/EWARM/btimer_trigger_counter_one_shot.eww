<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\btimer_trigger_counter_one_shot.ewp</path>
  </project>
  <batchBuild/>
</workspace>


