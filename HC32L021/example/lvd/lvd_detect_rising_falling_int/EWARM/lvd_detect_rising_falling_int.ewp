# IAR project lvd_detect_rising_falling_int.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: HC32L021C8PB XHSC HC32L021C8PB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lvd_detect_rising_falling_int.hex
  ILINK.IlinkOutputFile: lvd_detect_rising_falling_int.out
  ILINK.IlinkIcfFile: HC32L021.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: lvd_detect_rising_falling_int.srec
  group common
    ../../../../mcu/common/: system_hc32l021.c interrupts_hc32l021.c board_stkhc32l021.c
    ./: startup_hc32l021.s
  group driver
    ../../../../driver/src/: ddl.c sysctrl.c gpio.c gpio.c lvd.c
  group source
    ../source/: main.c
  group README
    ../: readme.txt
