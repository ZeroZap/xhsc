<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lvd_detect_rising_falling_int.ewp</path>
  </project>
  <batchBuild/>
</workspace>


