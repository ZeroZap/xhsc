<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\hsi2c_mcu_master_int.ewp</path>
  </project>
  <batchBuild/>
</workspace>


