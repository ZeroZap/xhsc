<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\atimer3_m0_tog.ewp</path>
  </project>
  <batchBuild/>
</workspace>


