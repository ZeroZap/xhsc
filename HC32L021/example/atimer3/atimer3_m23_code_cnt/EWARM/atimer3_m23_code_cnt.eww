<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\atimer3_m23_code_cnt.ewp</path>
  </project>
  <batchBuild/>
</workspace>


